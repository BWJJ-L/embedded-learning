# Keil uVision project project.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Lib;.\Driver;.\App;.\Driver\I2C_OLED;.\Driver\SPI_OLED
  group User
    ./: main.c
  group APP
    ./App/: App.h App_Keys.c App_OLED.c App_NTC.c App_LED.c App_Motor.c App_RTC.c App_NixieDigital.c App_DHT11.c App_MatrixKey_Buzzer.c
  group Driver
    ./Driver/: Keys.c NTC.c PCF8563.c NIXIE.c MatrixKey.c
    ./Driver/SPI_OLED/: SPI_OLED.c
    ./Driver/I2C_OLED/: I2C_OLED.c
  group Lib
    ./Lib/: Delay.c GPIO.c I2C.c I2C_Isr.c NVIC.c UART.c UART_Isr.c ADC.c ADC_Isr.c STC8H_PWM.c STC8H_PWM_Isr.c Timer.c Timer_Isr.c
  group OS
    ./OS/: Conf_tny.A51 RTX51TNY.LIB
