# Keil uVision project project.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver;.\Driver\OLED;.\Lib
  group Source Group 1
    ./: main.c
  group Lib
    ./Lib/: Delay.c GPIO.c GPIO_Isr.c NVIC.c UART.c UART_Isr.c
  group Driver
    ./Driver/OLED/: oled.c
