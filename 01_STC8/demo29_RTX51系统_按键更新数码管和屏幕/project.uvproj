# Keil uVision project project.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Lib;.\Driver;.\Driver\oled
  group User
    ./: main.c
  group OS
    ./OS/: Conf_tny.A51
  group Lib
    ./Lib/: Delay.c GPIO.c UART.c UART_Isr.c NVIC.c I2C.c I2C_Isr.c
  group Driver
    ./Driver/: NIXIE.c MatrixKey.c
    ./Driver/oled/: oled.c
