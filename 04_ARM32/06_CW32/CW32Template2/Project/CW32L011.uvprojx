# Keil uVision project CW32L011.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: CW32L011K8 WHXY
  pack: WHXY.CW32L011_DFP.1.0.1
  cpu: IRAM(0x20000000,0x01800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CW32L011 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c misc: -Wno-invalid-source-encoding
  c include: ..\User;..\Libraries\inc;..\Bsp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group User
    ../User/: interrupts_cw32l011.c main.c board.c
  group CMSIS
    ../Libraries/: startup_cw32l011.s
    ../Libraries/src/: system_cw32l011.c
  group Firmware
    ../Libraries/src/: cw32l011_gpio.c cw32l011_sysctrl.c cw32l011_systick.c cw32l011_uart.c
  group Bsp
    ../Bsp/: uart1.c
software components: CMSIS:CORE 5.6.0
