# Keil uVision project flash_FullChipErase.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ASM32F470K8xI Asemi
  pack: Asemi.ASM32F470_DFP.0.0.1
  cpu: IRAM(0x20000000,0x01800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\..\..\..\IdeSupport\MDK;..\..\..\..\Libraries\inc;..\USER\inc;..\..\..\..\StartKit_Board
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --keep=*Handler
  group Startup
    ../../../../IdeSupport/MDK/: startup_cw32l011.s
    ../../../../Libraries/src/: system_cw32l011.c
  group User
    ../USER/src/: main.c interrupts_cw32l011.c EraseInRam.c
  group Driver
    ../../../../Libraries/src/: cw32l011_flash.c cw32l011_gpio.c cw32l011_sysctrl.c cw32l011_systick.c cw32l011_uart.c
  group Doc
    ../: readme.txt
  group Bsp
    ../../../../StartKit_Board/: cw32l011_startkit_board.c
software components: CMSIS:CORE 5.3.0
