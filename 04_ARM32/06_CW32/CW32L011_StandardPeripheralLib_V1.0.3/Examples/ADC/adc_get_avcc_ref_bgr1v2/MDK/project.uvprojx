# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CW32L011K8 WHXY
  pack: WHXY.CW32L011_DFP.1.0.1
  cpu: IRAM(0x20000000,0x01800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\IdeSupport\MDK;..\..\..\..\Libraries\inc;..\USER\inc;..\..\..\..\StartKit_Board
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup
    ../../../../IDEsupport/MDK/: startup_cw32l011.s
    ../../../../Libraries/src/: system_cw32l011.c
  group User
    ../USER/src/: interrupts_cw32l011.c main.c
  group Driver
    ../../../../Libraries/src/: cw32l011_flash.c cw32l011_gpio.c cw32l011_sysctrl.c cw32l011_systick.c cw32l011_uart.c cw32l011_adc.c
  group BSP
    ../../../../StartKit_Board/: cw32l011_startkit_board.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.6.0
