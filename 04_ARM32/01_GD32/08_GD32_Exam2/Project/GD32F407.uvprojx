# Keil uVision project GD32F407.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407,HXTAL_VALUE=8000000
  c misc: -Wno-invalid-source-encoding
  c include: ..\User;..\Library;..\Library\usart;..\App;..\Hardware;..\Library\ADC;..\Library\SPI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: App.h App_debug.c App_fryer.c App_key.c
  group User
    ../User/: gd32f4xx_it.c systick.c main.c Task.c
  group Hardware
    ../Hardware/: bsp_led188.c bsp_led188.h bsp_adkey.c bsp_adkey.h bsp_ec12.c bsp_ec12.h bsp_ws2812.c bsp_ws2812.h
  group Library
    ../Library/usart/: USART0.c
    ../Library/: TIMER.c EXTI.c
    ../Library/ADC/: ADC0.c
    ../Library/SPI/: SPI1_hard.c
  group Config
    ../Library/: gpio_cfg.h TIMER_config.h EXTI_config.h
    ../Library/ADC/: ADC0.h
software components: CMSIS:CORE 5.6.0, Device:Startup 3.0.2, Device:StdPeripherals:ADC 3.0.2, Device:StdPeripherals:DMA 3.0.2, Device:StdPeripherals:EXTI 3.0.2, Device:StdPeripherals:GPIO 3.0.2, Device:StdPeripherals:MISC 3.0.2, Device:StdPeripherals:PMU 3.0.2, Device:StdPeripherals:RCU 3.0.2, Device:StdPeripherals:SPI_I2S 3.0.2, Device:StdPeripherals:SYSCFG 3.0.2, Device:StdPeripherals:TIMER 3.0.2, Device:StdPeripherals:USART 3.0.2
