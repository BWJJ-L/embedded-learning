# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Lib
  group User
    ./: main.c
  group OS
    ./OS/: Conf_tny.A51
  group Lib
    ./Lib/: GPIO.c Delay.c NVIC.c UART.c UART_Isr.c
