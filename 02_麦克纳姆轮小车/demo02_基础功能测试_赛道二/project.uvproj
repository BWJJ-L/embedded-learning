# Keil uVision project project.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver;.\Lib
  group Source Group 1
    ./: main.c
  group Driver
    ./Driver/: Light.c light.h Key.c Key.h battery.c battery.h Buzzer.c Buzzer.h Ultrasonic.c Ultrasonic.h Motors.c Motors.h Track.c Track.h
  group Lib
    ./Lib/: GPIO.c NVIC.c UART.c UART_Isr.c ADC.c ADC_Isr.c STC8H_PWM.c STC8H_PWM_Isr.c
  group OS
    ./OS/: Conf_tny.A51 RTX51TNY.LIB
